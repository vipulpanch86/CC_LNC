# Keil uVision project UserInterfaceController.uvproj, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UserInterfaceController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\Source\Common\CMSIS\CM3\CoreSupport;..\..\Source\Common\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Source\Common\STM32F10x_StdPeriph_Driver\inc;..\..\Source\UserInterfaceController\Environment\inc;..\..\Source\UserInterfaceController\BoardSupport\inc;..\..\Source\Common\Utilities\inc;..\..\Source\UserInterfaceController\Application\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../Source/Common/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../../Source/Common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Environment
    ../../Source/UserInterfaceController/Environment/src/: startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_it.c
  group BoardSupport
    ../../Source/UserInterfaceController/BoardSupport/src/: bsp.c LCD_X_8080_8.c bsp_keypad.c ili9341.c
  group Utilities
    ../../Source/Common/Utilities/src/: sys_timer_utils.c
  group Application
    ../../Source/UserInterfaceController/Application/src/: main.c
  group Test
    ../../Source/UserInterfaceController/Test/: TestKeypad.c
